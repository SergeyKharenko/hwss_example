# Keil uVision project CH394Q_TCP_SERVER.uvprojx, settings and files
target CH394Q_TCP_SERVER (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH394Q_TCP_SERVER +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\PUB;..\SRC\StdPeriphDriver\inc;..\SRC\DEBUG;..\SRC\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../SRC/CMSIS/Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../SRC/CMSIS/: core_cm3.c system_stm32f10x.c
  group Peripheral
    ../SRC/StdPeriphDriver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Debug
    ../SRC/DEBUG/: debug.c
  group PUB
    ../PUB/: CH394Q.c CH394Q_NET.c CH394Q_SPI.c
  group User
    ./: main.c
